# Keil uVision project espDemo.uvproj, settings and files
target esp8266 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: esp8266
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c pll.c FIFOqueue.c Switch.c SysTick.c Timer0A.c Timer1.c Timer3.c Timer4.c
  group FSM
    ./: MainMenu.c FSM.c heap.c Timer5.c PedometerScreen.c SongScreen.c SongMenu.c Timer4.c
  group Music
    ./: Music.c DAC.c
  group Wifi
    ./: esp8266.c UART.c
  group Utilities
    ./: LCD.c fixed.c ST7735.c
  group Accelerometer
    ./: Timer5.c AccelAvgFIFO.c Accelerometer.c
