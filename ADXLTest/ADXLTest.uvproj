# Keil uVision project ADXLTest.uvproj, settings and files
target ADCPrintResults (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCPrintResults
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s UART.c main.c ADCSWTrigger.c PLL.c AccelAvgFIFO.c Accelerometer.c DAC.c FIFO.c fixed.c heap.c Music.c Song.c ST7735.c Switch.c SysTick.c Timer0A.c Timer1.c Timer3.c Timer4.c Timer5.c
